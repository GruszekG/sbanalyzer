# Keil uVision project sba_meas_board.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test_prog_v01 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\program_testowy;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\src;.\inc;.\LIS3DH;.\L3G4200D;.\LPY4150AL;.\RFM73
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group UserCode
    ./src/: main.c stm32f10x_it.c commands.c
    ./inc/: stm32f10x_conf.h stm32f10x_it.h
  group StdPeriphDrv
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_flash.c misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_tim.c
  group CMSIS
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h core_cm3.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h system_stm32f10x.c stm32f10x.h
  group RVMDK
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group LIS3DH
    ./LIS3DH/: LIS3DH.c LIS3DH.h
  group L3G4200D
    ./L3G4200D/: L3G4200D.c L3G4200D.h
  group LPY4150AL
    ./LPY4150AL/: LPY4150AL.c LPY4150AL.h
  group RFM73
    ./RFM73/: RFM73.c RFM73.h
